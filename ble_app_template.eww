<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\SBM-v1.0-Alpha.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\SBM-v1.0-Alpha.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040e\s112\iar\SBM-v1.0-Alpha.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056e\s112\iar\SBM-v1.0-Alpha.ewp</path>
  </project>  <batchBuild/>
</workspace>